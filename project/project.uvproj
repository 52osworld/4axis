# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,
  c include: ..\user;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\STM32_USB-FS-Device_Driver\inc;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\user\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: iic.c main.c stm32f10x_it.c timer.c usart.c mpu6050.c spi.c nrf24l01.c pid.c motor.c imu.c
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_i2c.c misc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c
  group cmsis
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group start_up
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
